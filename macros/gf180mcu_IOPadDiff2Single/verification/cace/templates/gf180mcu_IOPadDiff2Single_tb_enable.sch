** sch_path: macros/gf180mcu_IOPadDiff2Single/verification/cace/templates/gf180mcu_IOPadDiff2Single_tb_enable.sch
**.subckt gf180mcu_IOPadDiff2Single_tb_enable
x1 vdd 0 vddo 0 inp inn vref out iref en gf180mcu_IOPadDiff2Single
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-15
Ven en 0 pwl(0 0 1u 0 1.01u CACE{vdd})
Vd dp 0 0
Vsup vsup 0 CACE{vdd}
Bref vsup iref I=CACE{i_ref}*tanh(max(v(vsup,iref),0)/0.1)
Rref vsup iref 100Meg
Ep inp vref dp 0 0.5
En inn vref dp 0 -0.5
RL out vref CACE{rload}
CL out 0 CACE{cload}
.save all @m.x1.xdrv.xop.m0[id]
.control
tran 5n 31u 0 20n
let vo = v(out) - v(vref)
meas tran glitch_max max vo from=1u to=31u
meas tran glitch_min min vo from=1u to=31u
let glitch = max(abs(glitch_max), abs(glitch_min))
let outside = abs(vo) gt 1e-3
let t_on = vecmax(time * outside) - 1u
meas tran iq_on find @m.x1.xdrv.xop.m0[id] at=30u
let iqp = abs(iq_on)
echo $&glitch $&t_on $&iqp > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
