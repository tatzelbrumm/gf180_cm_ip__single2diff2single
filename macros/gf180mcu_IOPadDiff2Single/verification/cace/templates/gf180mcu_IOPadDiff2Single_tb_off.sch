** sch_path: macros/gf180mcu_IOPadDiff2Single/verification/cace/templates/gf180mcu_IOPadDiff2Single_tb_off.sch
**.subckt gf180mcu_IOPadDiff2Single_tb_off
x1 vdd 0 vddo 0 inp inn vref out iref en gf180mcu_IOPadDiff2Single
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-12
Ven en 0 CACE{en_v}
Vd dp 0 0
Vsup vsup 0 CACE{vdd}
Bref vsup iref I=CACE{i_ref}*tanh(max(v(vsup,iref),0)/0.1)
Rref vsup iref 100Meg
Ep inp vref dp 0 0.5
En inn vref dp 0 -0.5
RL out vref CACE{rload}
CL out 0 CACE{cload}
.control
save all
tran 10n 5u
meas tran i1 find i(Vvdd) at=5u
meas tran i2 find i(Vvddo) at=5u
meas tran vo1 find v(vddo) at=5u
meas tran va1 find v(x1.a) at=5u
meas tran vb find v(x1.b) at=5u
meas tran vout1 find v(out) at=5u
meas tran vref1 find v(vref) at=5u
meas tran vn find v(x1.iref_en) at=5u
meas tran ir find i(Vsup) at=5u
let idd_off = -i1 - i2
let va_off = vo1 - va1
let vb_off = vb
let vout_off = vout1 - vref1
let iref_n = vn
let iref_off = -ir
echo $&idd_off $&va_off $&vb_off $&vout_off $&iref_n $&iref_off > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
