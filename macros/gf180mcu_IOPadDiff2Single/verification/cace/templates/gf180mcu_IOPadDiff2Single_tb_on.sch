** sch_path: macros/gf180mcu_IOPadDiff2Single/verification/cace/templates/gf180mcu_IOPadDiff2Single_tb_on.sch
**.subckt gf180mcu_IOPadDiff2Single_tb_on
x1 vdd 0 vddo 0 inp inn vref out iref en gf180mcu_IOPadDiff2Single
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-15
Ven en 0 CACE{en_v}
Vd dp 0 0
Vsup vsup 0 CACE{vdd}
Bref vsup iref I=CACE{i_ref}*tanh(max(v(vsup,iref),0)/0.1)
Rref vsup iref 100Meg
Ep inp vref dp 0 0.5
En inn vref dp 0 -0.5
RL out vref CACE{rload}
CL out 0 CACE{cload}
.control
save all
op
let iqp = abs(@m.x1.xdrv.xop.m0[id])
let idd = -i(Vvdd) - i(Vvddo)
dc Vd -0.4 0.4 0.01
let vo = v(out) - v(vref)
meas dc vop find vo at=0.2
meas dc von find vo at=-0.2
meas dc vos find vo at=0
let gain = (vop - von)/0.4
let iq_p = op1.iqp
let i_dd = op1.idd
echo $&gain $&vos $&iq_p $&i_dd > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
