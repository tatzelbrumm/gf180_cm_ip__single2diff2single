** sch_path: macros/ClassABBias/verification/cace/templates/ClassABBiasBGdn_tb_line.sch
**.subckt ClassABBiasBGdn_tb_line
x1 vdd 0 iout en en_b ClassABBiasBGdn
Vvdd vdd 0 CACE{vdd}
Ven en 0 'CACE{vdd}*CACE{en=1}'
Venb en_b 0 'CACE{vdd}*(1-CACE{en=1})'
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-13 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
Vs iout s 0
XNI s s 0 0 nfet_03v3 L=6u W=6u nf=1
.control
save all
dc Vvdd 3.0 3.6 0.3
let ii = abs(i(Vs))
let s_iout = (ii[2] - ii[0])/ii[1]/0.6
echo $&s_iout > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_bjt=bjt_typical}
.lib $::180MCU_MODELS/sm141064.ngspice diode_typical

**** end user architecture code
**.ends

* expanding   symbol:  ClassABBiasBGdn.sym # of pins=5
** sym_path: macros/ClassABBias/schematic/xschem/ClassABBiasBGdn.sym
** sch_path: macros/ClassABBias/schematic/xschem/ClassABBiasBGdn.sch
.subckt ClassABBiasBGdn vdd vss iout en en_b
*.iopin vdd
*.iopin vss
*.ipin en
*.ipin en_b
*.iopin iout
XE vdd vss en en_b vpg ks RefCoreEnable
XMS1 ks en_b vdd vdd pfet_03v3 L=50u W=0.22u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XMS3 vpg ks vss vss nfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XMS2 ks g vss vss nfet_03v3 L=1u W=10u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XPB cb vpg vdd vdd pfet_03v3 L=4u W=48u nf=4 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XPBC vpg vpc cb vdd pfet_03v3 L=2u W=48u nf=4 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XNB vpc g eb eb nfet_03v3 L=12u W=20u nf=2 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XR1B vss eb vss ppolyf_u_3k r_width=1u r_length=107.4u m=1
XR0 e2 eb vss ppolyf_u_3k r_width=1u r_length=32.8u m=1
XQ2 vss vss e2 pnp_05p00x05p00 m=8 par=8
XRC vpc vpg vss ppolyf_u_3k r_width=1u r_length=50u m=1
XPA ca vpg vdd vdd pfet_03v3 L=4u W=48u nf=4 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XPAC g vpc ca vdd pfet_03v3 L=2u W=48u nf=4 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XNA g g ea ea nfet_03v3 L=12u W=20u nf=2 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XR1A vss ea vss ppolyf_u_3k r_width=1u r_length=118.1u m=1
XQ1 vss vss ea pnp_05p00x05p00 m=1 par=1
XPO co vpg vdd vdd pfet_03v3 L=4u W=96u nf=8 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XPOC iout vpc co vdd pfet_03v3 L=2u W=96u nf=8 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
DPWA ea vdd diode_pw2dw area='12u * 30u ' pj='2*12u + 2*30u ' m=1
DPWB eb vdd diode_pw2dw area='12u * 30u ' pj='2*12u + 2*30u ' m=1
DDNW vss vdd diode_dw2ps area='30u * 60u ' pj='2*30u + 2*60u ' m=1
.ends


* expanding   symbol:  RefCoreEnable.sym # of pins=6
** sym_path: macros/PadEnable/schematic/xschem/RefCoreEnable.sym
** sch_path: macros/PadEnable/schematic/xschem/RefCoreEnable.sch
.subckt RefCoreEnable vdd vss en en_b vpg ks
*.iopin vdd
*.iopin vss
*.ipin en
*.ipin en_b
*.iopin vpg
*.iopin ks
XSPG vpg en vdd vdd pfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XSKS ks en_b vss vss nfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
.ends

.end
