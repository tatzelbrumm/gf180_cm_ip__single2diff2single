** sch_path: macros/gf180mcu_IOPadSingle2Diff/verification/cace/templates/gf180mcu_IOPadSingle2Diff_tb_input.sch
**.subckt gf180mcu_IOPadSingle2Diff_tb_input
Vvdd vdd 0 CACE{vdd}
Vdvdd dvdd 0 CACE{dvdd}
Vvcm vcm 0 CACE{vcm}
Vpad pad 0 CACE{vin}
Vin_meas pad net1 0
.save i(vin_meas)
x1 vdd outp vcm net1 outn 0 vdd gf180mcu_IOPadSingle2Diff
xpad pad dvdd 0 vdd 0 gf180mcu_ocd_io__asig_5p0
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control
save all
op
* current INTO the macro's in pin, and the voltage the protected gate node sees
let Iin = i(Vin_meas)
let Vprot = v(x1.in_prot)
echo $&Iin $&Vprot > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
* harness analog pad cell (open_pdks install of gf180mcu_ocd_io)
.include $env(PDK_ROOT)/$env(PDK)/libs.ref/gf180mcu_ocd_io/spice/gf180mcu_ocd_io.spice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice diode_CACE{corner_d}
.lib $::180MCU_MODELS/sm141064.ngspice res_CACE{corner_d}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_CACE{corner_d}

**** end user architecture code
**.ends

* expanding   symbol:  gf180mcu_IOPadSingle2Diff.sym # of pins=7
** sym_path: macros/gf180mcu_IOPadSingle2Diff/schematic/xschem/gf180mcu_IOPadSingle2Diff.sym
** sch_path: macros/gf180mcu_IOPadSingle2Diff/schematic/xschem/gf180mcu_IOPadSingle2Diff.sch
.subckt gf180mcu_IOPadSingle2Diff vdd outp vcm in outn vss en
*.iopin vdd
*.opin outp
*.ipin vcm
*.ipin in
*.opin outn
*.iopin vss
*.ipin en
XRcdm in_prot in vss ppolyf_u_1k_6p0 r_width=5e-6 r_length=1e-6 m=1
Dcdmp in_prot vdd diode_pd2nw_06v0 area='2u * 12u ' pj='2*2u + 2*12u ' m=1
Dcdmn vss in_prot diode_nd2ps_06v0 area='2u * 12u ' pj='2*2u + 2*12u ' m=1
xinen vdd vss en en_b in_prot in_en vcm InputEnable
xinv vdd vss en en_b EnableInv
.ends


* expanding   symbol:  InputEnable.sym # of pins=7
** sym_path: macros/PadEnable/schematic/xschem/InputEnable.sym
** sch_path: macros/PadEnable/schematic/xschem/InputEnable.sch
.subckt InputEnable vdd vss en en_b pin pout vpark
*.iopin vdd
*.iopin vss
*.ipin en
*.ipin en_b
*.iopin pin
*.iopin pout
*.ipin vpark
XTGP1 pout en_b pin vdd pfet_03v3 L=0.5u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XTGN1 pin en pout vss nfet_03v3 L=0.5u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XTGP2 vpark en pout vdd pfet_03v3 L=0.5u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XTGN2 pout en_b vpark vss nfet_03v3 L=0.5u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
.ends


* expanding   symbol:  EnableInv.sym # of pins=4
** sym_path: macros/PadEnable/schematic/xschem/EnableInv.sym
** sch_path: macros/PadEnable/schematic/xschem/EnableInv.sch
.subckt EnableInv vdd vss en en_b
*.iopin vdd
*.iopin vss
*.ipin en
*.opin en_b
XMP en_b en vdd vdd pfet_03v3 L=0.5u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XMN en_b en vss vss nfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
.ends

.end
