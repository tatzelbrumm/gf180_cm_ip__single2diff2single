** sch_path: macros/ClassABDriver/verification/cace/templates/ClassABDriverBiased_tb_noise.sch
**.subckt ClassABDriverBiased_tb_noise
x1 vdd 0 vddo 0 vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn ClassABDriverBiased
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-15
Vd dp 0 0 ac 1
Ep vinp vref dp 0 0.5
En vinn vref dp 0 -0.5
RL vout vref CACE{rload}
CL vout 0 CACE{cload}
.control
save all
noise v(vout) Vd dec 20 10 10meg
setplot noise2
let vn_total = onoise_total
echo $&vn_total > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
