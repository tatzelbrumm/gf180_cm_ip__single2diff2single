** sch_path: macros/ClassABDriver/verification/cace/templates/ClassABDriverBiased_tb_loop.sch
**.subckt ClassABDriverBiased_tb_loop
x1 vdd 0 vddo 0 vinp vinn vref vout fb vbp vbn vbpc vbnc vabp vabn ClassABDriverBiased
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-15
Vd dp 0 0
Ep vinp vref dp 0 0.5
En vinn vref dp 0 -0.5
RL vout vref CACE{rload}
CL vout 0 CACE{cload}
Lb vout fb 1G
Cb fb inj 1
Vinj inj 0 dc 0 ac 1
.control
save all
ac dec 50 10 1G
let T = -v(vout)/v(fb)
meas ac T0 find vdb(T) at=10
meas ac fc when vdb(T)=0
meas ac pT find vp(T) when vdb(T)=0
let pm = 180/pi*pT + 180
echo $&T0 $&fc $&pm > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
