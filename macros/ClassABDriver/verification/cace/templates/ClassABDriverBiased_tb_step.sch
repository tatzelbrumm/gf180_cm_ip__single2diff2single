** sch_path: macros/ClassABDriver/verification/cace/templates/ClassABDriverBiased_tb_step.sch
**.subckt ClassABDriverBiased_tb_step
x1 vdd 0 vddo 0 vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn ClassABDriverBiased
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-15
Vd dp 0 pulse(-0.5 0.5 1u 1n 1n 4u 8u)
Ep vinp vref dp 0 0.5
En vinn vref dp 0 -0.5
RL vout vref CACE{rload}
CL vout 0 CACE{cload}
.control
save all
tran 2n 5u 0 5n
meas tran vlo find v(vout) at=0.99u
meas tran vhi find v(vout) at=4.9u
meas tran vmax max v(vout) from=1u to=5u
let overshoot = (vmax - vhi)/(vhi - vlo)
let v10 = vlo + 0.1*(vhi - vlo)
let v90 = vlo + 0.9*(vhi - vlo)
meas tran t10 when v(vout)=v10 rise=1
meas tran t90 when v(vout)=v90 rise=1
let slew = 0.8*(vhi - vlo)/(t90 - t10)
let outside = abs(v(vout) - vhi) gt 0.01*(vhi - vlo)
let t_settle = vecmax(time * outside) - 1u
echo $&overshoot $&slew $&t_settle > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
