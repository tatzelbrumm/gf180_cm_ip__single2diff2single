** sch_path: macros/ClassABDriver/verification/cace/templates/ClassABDriverBiased_tb_dc.sch
**.subckt ClassABDriverBiased_tb_dc
x1 vdd 0 vddo 0 vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn ClassABDriverBiased
Vvdd vdd 0 CACE{vdd}
Vvddo vddo 0 CACE{vdd}
Vref vref 0 CACE[CACE{vdd}/2]
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents reltol=1e-4 abstol=1e-12 gmin=1e-15
Vd dp 0 0
Ep vinp vref dp 0 0.5
En vinn vref dp 0 -0.5
RL vout vref CACE{rload}
CL vout 0 CACE{cload}
.control
save all
op
let iqp = abs(@m.x1.xd.xop.m0[id])
let iqn = abs(@m.x1.xd.xon.m0[id])
let idd = -i(Vvdd) - i(Vvddo)
dc Vd -1 1 0.01
let vo = v(vout) - v(vref)
meas dc vop find vo at=0.2
meas dc von find vo at=-0.2
meas dc vos find vo at=0
let gain = (vop - von)/0.4
let inrange = abs(v(dp)) le 0.4001
let inl = vecmax(abs(vo - gain*v(dp) - vos) * inrange)
let iq_p = op1.iqp
let iq_n = op1.iqn
let i_dd = op1.idd
echo $&gain $&vos $&inl $&iq_p $&iq_n $&i_dd > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_mos}
.lib $::180MCU_MODELS/sm141064.ngspice CACE{corner_res=res_typical}
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.param sw_stat_mismatch=CACE{mm=0}

**** end user architecture code
**.ends
.end
